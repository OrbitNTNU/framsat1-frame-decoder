options:
  parameters:
    author: Orbit NTNU
    generate_options: no_gui
    id: framsat1_rtlsdr_rx
    output_language: python
    title: framsat1_rtlsdr_rx
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: lo_freq
  id: variable
  parameters:
    value: 435.141e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x00'
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '500'
    min: '16'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 40e3
    decim: '25'
    gain: '1'
    samp_rate: 2.4e6
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_2
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: lo_freq
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: 2.4e6
    sync: sync
    type: fc32
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baudrate
    iq: 'True'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: line_shift
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: RTL_SDR_source
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: line_shift
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: RTL_SDR_source
  states: {}

connections:
- [digital_binary_slicer_fb_0, '0', satellites_nrzi_decode_0, '0']
- [digital_descrambler_bb_0, '0', digital_hdlc_deframer_bp_0, '0']
- [digital_hdlc_deframer_bp_0, out, blocks_message_debug_0, print]
- [digital_hdlc_deframer_bp_0, out, network_socket_pdu_2, pdus]
- [low_pass_filter_0, '0', virtual_sink_1, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [satellites_fsk_demodulator_0, '0', digital_binary_slicer_fb_0, '0']
- [satellites_nrzi_decode_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', digital_descrambler_bb_0, '0']
- [virtual_source_1, '0', satellites_fsk_demodulator_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
